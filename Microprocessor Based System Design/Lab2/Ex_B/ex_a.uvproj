# Keil uVision project ex_a.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M1 (Altera) ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: ex_a
  c flags: Optim=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup Sequence
    ../: startup.s
  group C Source
    ./: Odd_Even_LED.c
