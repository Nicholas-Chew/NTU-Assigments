# Keil uVision project Blinking_Even_Odd.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: Blinking_Even_Odd
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: Blink_Even_Odd.s
