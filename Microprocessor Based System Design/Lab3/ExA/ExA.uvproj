# Keil uVision project ExA.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M1 (Altera) ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: ExA
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup Source
    ./: startup.s
  group C Source
    ./: main3A.c i2c.c
  group Header File
    ./: i2c.h main3.h
